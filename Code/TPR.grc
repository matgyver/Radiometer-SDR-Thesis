options:
  parameters:
    author: Matthew Nelson
    category: Radiometer
    copyright: 2016-2021
    description: Blocks for power detection, integration and LPF for a total power radiometer
    generate_options: hb
    id: TPR
    output_language: python
    title: Total Power Radiometer
  states: {}

blocks:
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_4
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/det_rate)
    type: float
  states: {}
- name: det_rate
  id: parameter
  parameters:
    label: decimation rate
    value: '1'
  states: {}
- name: integ
  id: parameter
  parameters:
    label: Integration value
    value: '1'
  states: {}
- name: note_0
  id: note
  parameters:
    note: I^2+Q^2, PWR detection
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Integration
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: DECIMATE, LPF
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample Rate
    value: '1'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    affinity: '1'
    alpha: 1.0/((samp_rate*integ)/2.0)
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_4, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_4, '0']

metadata:
  file_format: 1
